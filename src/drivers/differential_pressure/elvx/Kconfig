## src/drivers/differential_pressure/elvx/Kconfig
```kconfig
menuconfig DRIVERS_DIFFERENTIAL_PRESSURE_ELVX
	bool "elvx"
	default n
	---help---
		Enable support for elvx
```
